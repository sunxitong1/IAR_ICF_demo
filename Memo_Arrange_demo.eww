<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\Memo_Arrange_demo.ewp</path>
    </project>
    <batchBuild/>
</workspace>
