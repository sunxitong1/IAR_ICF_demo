# IAR project Memo_Arrange_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G075M24_CPU0 Renesas R9A07G075M24_CPU0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _RENESAS_RZT_; _RZT_CORE=CR52_0
  ICCARM.CCIncludePath2: rzt/arm/CMSIS_5/CMSIS/Core_R/Include; rzt/fsp/inc; rzt/fsp/inc/api; rzt/fsp/inc/instances; rzt_cfg/fsp_cfg; rzt_cfg/fsp_cfg/bsp; rzt_gen; src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RENESAS_RZT_; _RZT_CORE=CR52_0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: Memo_Arrange_demo.out
  ILINK.IlinkIcfFile: script/fsp_xspi0_boot.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RZT_; _RZT_CORE=CR52_0
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rzt_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    rzt_cfg/fsp_cfg/: r_ioport_cfg.h
  group Flex Software/Components
    rzt/board/rzt2m_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzt/fsp/inc/api/: bsp_api.h r_ioport_api.h
    rzt/fsp/src/bsp/mcu/rzt2m/: bsp_cache.c bsp_cache.h bsp_elc.h bsp_feature.h bsp_loader_param.c bsp_mcu_info.h
    rzt/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_semaphore.c bsp_semaphore.h bsp_tfu.h
    rzt/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzt/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzt/arm/CMSIS_5/: LICENSE.txt
    rzt/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R9A07G074.h R9A07G075.h renesas.h system.h
    rzt/fsp/src/r_ioport/: r_ioport.c
    rzt/fsp/inc/instances/: r_ioport.h
    rzt/fsp/src/bsp/cmsis/Device/RENESAS/SVD/: RA.svd
    rzt/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    rzt_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c
